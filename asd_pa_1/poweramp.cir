* EESchema Netlist Version 1.1 (Spice format) creation date: ti. 20. jan. 2015 kl. 18.37 +0100

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

*Sheet Name:/
Q9  Net-_C5-Pad1_ Net-_Q9-Pad2_ Net-_C4-Pad2_ BC546
Q8  Net-_C5-Pad1_ Net-_Q6-Pad1_ Net-_Q6-Pad2_ BC556
Q6  Net-_Q6-Pad1_ Net-_Q6-Pad2_ VCC BC556
Q10  Net-_C4-Pad2_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ BC546
Q7  GND Net-_C4-Pad1_ Net-_Q10-Pad2_ BC546
Q4  Net-_Q2-Pad2_ Net-_Q2-Pad2_ Net-_Q4-Pad3_ BC546
Q2  Net-_C4-Pad1_ Net-_Q2-Pad2_ Net-_Q2-Pad3_ BC546
Q5  Net-_Q2-Pad2_ Net-_Q5-Pad2_ Net-_Q5-Pad3_ BC556
Q1  Net-_C4-Pad1_ Net-_C2-Pad2_ Net-_Q1-Pad3_ BC556
Q3  Net-_Q3-Pad1_ Net-_D1-Pad1_ Net-_Q3-Pad3_ BC556
C5  Net-_C5-Pad1_ Net-_C4-Pad2_ 10u
R21  /Protection/AmpOut Net-_Q14-Pad3_ 0.22
D3  VEE /Protection/Gnd 1N4004
D2  /Protection/Gnd VCC 1N4004
R20  Net-_Q13-Pad3_ /Protection/AmpOut 0.22
R2  GND /in_gnd 4.7
C9  /Protection/Gnd VEE 220u
C7  VCC /Protection/Gnd 220u
R19  /Protection/AmpOut Net-_Q12-Pad1_ 33
R3  /in_gnd Net-_C2-Pad2_ 20k
C2  Net-_C1-Pad1_ Net-_C2-Pad2_ 4.7u
C1  Net-_C1-Pad1_ /in_gnd 270p
R1  /in Net-_C1-Pad1_ 2.2k
C3  /in_gnd Net-_C3-Pad2_ 220u
C4  Net-_C4-Pad1_ Net-_C4-Pad2_ 100p
R10  Net-_C3-Pad2_ Net-_Q5-Pad2_ 820
R11  Net-_Q5-Pad2_ /Protection/AmpOut 20k
R18  Net-_Q11-Pad1_ /Protection/AmpOut 33
R12  Net-_Q6-Pad1_ GND 56k
R16  VCC Net-_Q6-Pad2_ 68
XRV1  Net-_Q9-Pad2_ Net-_R15-Pad1_ Net-_R15-Pad1_ POT_1K
R7  VCC Net-_Q3-Pad3_ 6.8k
R15  Net-_R15-Pad1_ Net-_C4-Pad2_ 1.8k
R14  Net-_C5-Pad1_ Net-_Q9-Pad2_ 4.7k
R4  Net-_D1-Pad1_ GND 47k
D1  Net-_D1-Pad1_ VCC Z8_2
R17  Net-_Q10-Pad3_ VEE 22
R13  Net-_Q10-Pad2_ VEE 330
R9  Net-_Q4-Pad3_ VEE 470
R6  Net-_Q2-Pad3_ VEE 470
R8  Net-_Q3-Pad1_ Net-_Q5-Pad3_ 470
R5  Net-_Q3-Pad1_ Net-_Q1-Pad3_ 470
C6  VCC /Protection/Gnd 100n
C8  VEE /Protection/Gnd 100n
Q11  VCC Net-_C5-Pad1_ Net-_Q11-Pad1_ MJE243C		;Node Sequence Spec.<2,3,1>
Q13  VCC Net-_Q11-Pad1_ Net-_Q13-Pad3_ MJL21194C		;Node Sequence Spec.<2,1,3>
Q12  VEE Net-_C4-Pad2_ Net-_Q12-Pad1_ MJE253C		;Node Sequence Spec.<2,3,1>
Q14  VEE Net-_Q12-Pad1_ Net-_Q14-Pad3_ MJL21193C		;Node Sequence Spec.<2,1,3>
*Sheet Name:/Protection/
Q16  Net-_Q16-Pad1_ Net-_D5-Pad1_ Net-_Q15-Pad3_ BC556
Q18  VCC Net-_Q17-Pad3_ Net-_Q18-Pad3_ BC546
Q17  VCC /Protection/Mute Net-_Q17-Pad3_ BC546
Q15  /Protection/Mute Net-_D4-Pad2_ Net-_Q15-Pad3_ BC546
D10  VEE /Protection/Speaker 1N4004
R27  Net-_C12-Pad2_ Net-_L1-Pad1_ 100
C12  /Protection/AmpOut Net-_C12-Pad2_ 10u
R26  /Protection/Gnd Net-_Q17-Pad3_ 100k
D6  /Protection/Gnd Net-_D4-Pad2_ 1N4148
D7  Net-_D5-Pad1_ /Protection/Gnd 1N4148
R25  VEE Net-_Q16-Pad1_ 4.7k
R24  /Protection/Mute VCC 100k
R22  /Protection/AmpOut Net-_C10-Pad1_ 47k
C10  Net-_C10-Pad1_ /Protection/Gnd 47u
D5  Net-_D5-Pad1_ Net-_C10-Pad1_ 1N4148
D4  Net-_C10-Pad1_ Net-_D4-Pad2_ 1N4148
D8  /Protection/Gnd Net-_D8-Pad2_ 1N4004
R28  Net-_D8-Pad2_ Net-_Q18-Pad3_ 270
D9  /Protection/Speaker VCC 1N4004
C11  /Protection/AmpOut Net-_C11-Pad2_ 100n
R23  Net-_C11-Pad2_ /Protection/GndZ 10
L1  Net-_L1-Pad1_ /Protection/Speaker 2u
R29  Net-_L1-Pad1_ /Protection/Speaker 10
XK1  Net-_D8-Pad2_ /Protection/Gnd /Protection/AmpOut Net-_L1-Pad1_ /Protection/Gnd RELAY_SPDT

.include "amp_sim.txt"

.end
